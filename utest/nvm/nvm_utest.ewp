# IAR project nvm_utest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; DEBUG_MCO
  ICCARM.CCIncludePath2: ..\..\hal\stm32f107x\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\hal\stm32f107x\STM32F10x_StdPeriph_Driver\inc; ..\..\hal\stm32f107x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nvm_utest.srec
  ILINK.IlinkOutputFile: nvm_utest.out
  ILINK.IlinkKeepSymbols: msg
  ILINK.IlinkIcfFile: F:\sp\blade\tls-x.blade.fw\mos\utest\nvm\stm32f107xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group hal
    ../../hal/stm32f107x/: hw.c nvm.c sys.c
  group hal/cmsis
    ../../hal/stm32f107x/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../hal/stm32f107x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group hal/startup
    ../../hal/stm32f107x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group hal/StdPeriph_Driver
    ../../hal/stm32f107x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group utest
    ./: nvm_utest.c
