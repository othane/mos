# IAR project crc_utest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; DEBUG_MCO; CRC_SOFT; CRC_HARD
  ICCARM.CCIncludePath2: ..\..\hal\stm32f107x\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\hal\stm32f107x\STM32F10x_StdPeriph_Driver\inc; ..\..\hal\stm32f107x; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: crc_utest.srec
  ILINK.IlinkOutputFile: crc_utest.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f107xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group hal
    ../../hal/stm32f107x/: crc.c crcmodel.c sys.c
    ./: hw.c
  group hal/cmsis
    ../../hal/stm32f107x/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../hal/stm32f107x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group hal/startup
    ../../hal/stm32f107x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group hal/StdPeriph_Driver
    ../../hal/stm32f107x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group utest
    ./: crc_utest.c
